Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-05-04T16:13:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 04 16:13:04 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{73CD37E8-3D8E-42FE-BE58-4643C275FFD8}\ifc * Database version: 5507 * Database creation date: Wed May 04 16:13:04 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 04 16:13:04 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 04 16:13:04 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: MODULE 70, 2015_Sofa_Viccarbe_STEP-Module:MODULE 70:138184
In: Nivel 1
Type - ElementType: MODULE 70; Material: Linen - Beige, Seams - Red, Chromed steel frame
Type - Construction - Backrest: yes; Base: yes
Type - Dimensions - Depth (inches): 37.40"; Depth (mm): 950 mm; Height (inches): 25.59"; Height (mm): 650 mm; Width (inches): 27.55"; Width (mm): 700 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: STEP; Content Revision Date: 27/04/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Modular sofa of exquisite proportions, multiple compositions and surprising comfort. Its hand stitched seams add warmth to this unique architectural collection; Designer: VINCENT VAN DUYSEN; Essays BIFMA: http://www.viccarbe.com/archivos/step-certificado-une-bifma-en.pdf; Essays UNE: http://www.viccarbe.com/archivos/step-certificado-une-bifma-en.pdf; General Dimensions (inches): 25.59"x27.55"x37.40"; General Dimensions (mm): 650x700x950 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: MODULE 70; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=3951653aa8a9884; Reference Code: ST70; Technical information: http://www.viccarbe.com/archivos/viccarbe-step-en-26.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: MODULE 70; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Backrest Material: Linen - Beige; Base Material: Chromed steel frame; Cushion Material: Linen - Red; Materials - Fabrics: http://www.viccarbe.com/archivos/VICCARBE_Kvadrat_fabrics.pdf; Materials - Leather: http://www.viccarbe.com/archivos/VICCARBE_leather.pdf; Materials - Vinyl: http://www.viccarbe.com/archivos/VICCARBE_polipiel_vinyl.pdf; Seams Material: Seams - Red; Seat Material: Linen - Beige
Type - Other - Category: Furniture; Backrest Height 2 (mm): 480 mm; Backrest Length (mm): 700 mm; Family Name: 2015_Sofa_Viccarbe_STEP-Module; Seat Height (mm): 360 mm; Width 2 (mm): 700 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Sofa_Viccarbe_STEP-Module: MODULE 70; Tipo: 2015_Sofa_Viccarbe_STEP-Module: MODULE 70; Descripción: Modular sofa of exquisite proportions, multiple compositions and surprising comfort. Its hand stitched seams add warmth to this unique architectural collection; Fabricante: VICCARBE; Modelo: MODULE 70; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Arm Left: no; Arm Right: no; Narrow Arm: yes; STAL25 -Cushion: no; STAL50 -Cushion: no; Wide Arm: no
Dimensions - Area: 3.10546 m2; STAL 25 - Situation (mm): 63.2671 mm; STAL 25 - Situation 2 (mm): 74.0705 mm; STAL 50 - Situation (mm): 285 mm; STAL 50 - Situation 2 (mm): 9.07054 mm; Volume: 0.257915 m3
Other - Backrest Depth (mm): 125 mm; Family: 2015_Sofa_Viccarbe_STEP-Module: MODULE 70; Family and Type: 2015_Sofa_Viccarbe_STEP-Module: MODULE 70; Type: 2015_Sofa_Viccarbe_STEP-Module: MODULE 70; Type Id: 2015_Sofa_Viccarbe_STEP-Module: MODULE 70
Phasing - Phase Created: Fase 1
