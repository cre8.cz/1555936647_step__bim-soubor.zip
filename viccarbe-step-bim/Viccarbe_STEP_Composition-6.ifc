Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-05-04T16:11:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 04 16:11:28 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{AE8EF090-C7EE-4FE6-A27F-1D71410A6E1B}\ifc * Database version: 5507 * Database creation date: Wed May 04 16:11:28 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 04 16:11:28 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 04 16:11:28 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: COMPOSITION 6, 2015_Sofa_Viccarbe_STEP-Compositions:COMPOSITION 6:137039
In: Nivel 1
Type - ElementType: COMPOSITION 6; Material: Chromed steel frame, Linen - Beige, Seams - Red
Type - Dimensions - Height (inches): 25.59"; Height (mm): 650 mm; Length (inches): 140.4"; Length (mm): 3600 mm; Width (inches): 74.80"; Width (mm): 1900 mm
Type - Identity Data - Bimetica: http://www.bimetica.com/; Collection: STEP; Content Revision Date: 01/03/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Modular sofa of exquisite proportions, multiple compositions and surprising comfort. Its hand stitched seams add warmth to this unique architectural collection; Designer: VINCENT VAN DUYSEN; Essays BIFMA: http://www.viccarbe.com/archivos/step-certificado-une-bifma-en.pdf; Essays UNE: http://www.viccarbe.com/archivos/step-certificado-une-bifma-en.pdf; General Dimensions (inches): 25.59"x140.4"x74.80"; General Dimensions (mm): 650x3600x1900 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: COMPOSITION 6; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=3951653aa8a9884; Reference Code: -; Technical information: http://www.viccarbe.com/archivos/viccarbe-step-en-26.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: COMPOSITION 6; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Backrest Material: Linen - Beige; Base Material: Chromed steel frame; Cushion Material: Linen - Red; Materials - Fabrics: http://www.viccarbe.com/archivos/VICCARBE_Kvadrat_fabrics.pdf; Materials - Leather: http://www.viccarbe.com/archivos/VICCARBE_leather.pdf; Materials - Vinyl: http://www.viccarbe.com/archivos/VICCARBE_polipiel_vinyl.pdf; Seams Material: Seams - Red; Seat Material: Linen - Beige
Type - Other - Category: Furniture; Family Name: 2015_Sofa_Viccarbe_STEP-Compositions; Module 1: no; Module 10: no; Module 11: yes; Module 2: no; Module 3: no; Module 4: no; Module 4 Distance: 2950 mm; Module 5: no; Module 6: yes; Module 6 Distance: 900 mm; Module 7: yes; Module 8: no; Module 9: no
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Sofa_Viccarbe_STEP-Compositions: COMPOSITION 6; Tipo: 2015_Sofa_Viccarbe_STEP-Compositions: COMPOSITION 6; Descripción: Modular sofa of exquisite proportions, multiple compositions and surprising comfort. Its hand stitched seams add warmth to this unique architectural collection; Fabricante: VICCARBE; Modelo: COMPOSITION 6; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 62.6073 m2; Volume: 5.79627 m3
Other - Family: 2015_Sofa_Viccarbe_STEP-Compositions: COMPOSITION 6; Family and Type: 2015_Sofa_Viccarbe_STEP-Compositions: COMPOSITION 6; Type: 2015_Sofa_Viccarbe_STEP-Compositions: COMPOSITION 6; Type Id: 2015_Sofa_Viccarbe_STEP-Compositions: COMPOSITION 6
Phasing - Phase Created: Fase 1
